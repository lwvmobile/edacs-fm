options:
  parameters:
    author: lwvmobile
    generate_options: no_gui
    id: EDACS_Radio_Combined_no_GUI_38
    output_language: python
    title: EDACS Radio Combined no GUI 38
  states: {}

blocks:
- name: cutoff
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: freqcc
  id: variable
  parameters:
    value: '850000000'
  states: {}
- name: freqlcn
  id: variable
  parameters:
    value: '850000000'
  states: {}
- name: ppmcc
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ppmlcn
  id: variable
  parameters:
    value: '0'
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: int(samp_rate/4)
  states: {}
- name: rfgain
  id: variable
  parameters:
    value: '42'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: sqlcn
  id: variable
  parameters:
    value: '-150'
  states: {}
- name: transition
  id: variable
  parameters:
    value: '1500'
  states: {}
- name: volume
  id: variable
  parameters:
    value: '3'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sqlcn
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: quadrature
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: quadrature
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_endian_swap_0
  id: blocks_endian_swap
  parameters:
    type: s16
  states: {}
- name: blocks_endian_swap_0_0
  id: blocks_endian_swap
  parameters:
    type: s16
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '500'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '500'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {state: disabled}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '2000'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '2001'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: EDACS-CC.wav
    samp_rate: samp_rate
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: quadrature
    interp: '48000'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: quadrature
    interp: '48000'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    corr0: ppmcc
    freq0: freqcc
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rtlsdr_source_1
  id: rtlsdr_source
  parameters:
    args: rtl=1
    bb_gain0: '20'
    corr0: ppmlcn
    freq0: freqlcn
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', analog_wfm_rcv_0_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1, '0']
- [analog_wfm_rcv_0_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_endian_swap_0, '0', blocks_udp_sink_0, '0']
- [blocks_endian_swap_0_0, '0', blocks_udp_sink_0_0, '0']
- [blocks_float_to_short_0, '0', blocks_endian_swap_0, '0']
- [blocks_float_to_short_0_0, '0', blocks_endian_swap_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0_0, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_float_to_short_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_wavfile_sink_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_float_to_short_0_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rtlsdr_source_1, '0', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
