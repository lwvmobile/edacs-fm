options:
  parameters:
    author: lwvmobile
    generate_options: no_gui
    id: EDACS_Radio_Combined_no_GUI_3930A
    output_language: python
    title: EDACS Radio Combined no GUI 3930 Airspy
  states: {}

blocks:
- name: cutoff
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: freqcc
  id: variable
  parameters:
    value: 850e6
  states: {}
- name: freqlcn
  id: variable
  parameters:
    value: 850e6
  states: {}
- name: ppmcc
  id: variable
  parameters:
    value: '49'
  states: {}
- name: ppmlcn
  id: variable
  parameters:
    value: '-2.0'
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: samp_rate/4
  states: {}
- name: rfgain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6e6
  states: {}
- name: sqlcn
  id: variable
  parameters:
    value: '-150'
  states: {}
- name: transition
  id: variable
  parameters:
    value: '1500'
  states: {}
- name: variable_config_0
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: real
    value: '0'
    writeback: None
  states: {}
- name: volume
  id: variable
  parameters:
    value: '5'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sqlcn
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: quadrature
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: quadrature
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_endian_swap_0_0
  id: blocks_endian_swap
  parameters:
    type: s16
  states: {}
- name: blocks_endian_swap_0_0_0
  id: blocks_endian_swap
  parameters:
    type: s16
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '500'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '700'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: SLERS-CC.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_sink_1_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: short
  states: {}
- name: network_udp_sink_1_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2001'
    send_eof: 'False'
    type: short
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"airspy=0"'
    bb_gain0: '20'
    bb_gain1: '20'
    corr0: ppmcc
    corr1: ppmlcn
    dc_offset_mode1: '0'
    freq0: freqcc
    freq1: freqlcn
    gain0: rfgain
    gain1: rfgain
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(quadrature)
    interp: int(48e3)
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(quadrature)
    interp: int(48e3)
    type: fff
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/quadrature)
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_2_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/quadrature)
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', analog_wfm_rcv_0_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_endian_swap_0_0, '0', network_udp_sink_1_0, '0']
- [blocks_endian_swap_0_0_0, '0', network_udp_sink_1_0_0, '0']
- [blocks_float_to_short_0, '0', blocks_endian_swap_0_0, '0']
- [blocks_float_to_short_0_0, '0', blocks_endian_swap_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0_0, '0', analog_simple_squelch_cc_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_2, '0']
- [osmosdr_source_0, '1', rational_resampler_xxx_2_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_wavfile_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_float_to_short_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_2, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_2_0, '0', low_pass_filter_0_0, '0']

metadata:
  file_format: 1
